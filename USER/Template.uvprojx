# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F102C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2800) CPUTYPE("Cortex-M3") CLOCK(48000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWAVE\LED;..\HARDWAVE\IIC;..\HARDWAVE\GY-85;..\HARDWAVE\KEY;..\HARDWAVE\LCD;..\HARDWAVE\SDIO;..\MALLOC;..\SYSTEM\usart;..\HARDWAVE\GY-85;..\HARDWAVE\SPI;..\HARDWAVE\SD;..\HARDWAVE\OLED;..\HARDWAVE\OLED;..\HARDWAVE\WS2812;..\HARDWAVE\DHT11
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_can.c
  group HARDWAVE
    ../HARDWAVE/led/: led.c
    ../HARDWAVE/GY-85/: GY-85_1.c
    ../HARDWAVE/SPI/: spi.c
    ../HARDWAVE/OLED/: oled.c
    ../HARDWAVE/WS2812/: ws2812.c
    ../HARDWAVE/DHT11/: dht11.c
  group README
    ../: README.TXT
